# Keil uVision project Hua-Robot.uvprojx, settings and files
target Robot (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hua-F103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,define STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\Function\function;..\User\Function\function_ADC;..\User\Modules\LED;..\User\Modules\Sensor;..\User\Modules\Sensor_ADC;..\User\Modules\usart;..\User\Modules\usart2;..\User\Modules\Motor;..\User\Modules\beep;..\User\Modules\DHT11;..\User\Modules\flash;..\User\Modules\i2c;..\User\Modules\SysTick;..\User\Modules\font;..\User\Function\Function_LCD;..\User\Modules\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group Modules
    ../User/Modules/Sensor/: sensor.c
    ../User/Modules/Sensor_ADC/: Sensor_ADC.c
    ../User/Modules/Motor/: Motor.c
    ../User/Modules/LED/: Led.c
    ../User/Modules/usart/: usart.c
    ../User/Modules/usart2/: usart2.c
    ../User/Modules/beep/: beep.c
    ../User/Modules/flash/: SPI_flash.c
    ../User/Modules/lcd/: LCD_ili9341.c
    ../User/Modules/SysTick/: SysTick.c
    ../User/Modules/font/: fonts.c
    ../User/Modules/DHT11/: DHT11.c
  group Function
    ../User/Function/Function/: Function.c
    ../User/Function/Function_ADC/: Function_ADC.c
    ../User/Function/Function_LCD/: Function_LCD.c
  group DOC
    ../Doc/: readme.txt
